Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-29T00:05:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 29 00:05:33 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\27e10a7c-5499-4815-b434-dff833330d36\ifc * Database version: 5507 * Database creation date: Mon Jan 29 00:05:31 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 29 00:05:32 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 29 00:05:32 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 7401GL Shower system, 7401GL(2023):7401GL Shower system:86185
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm; ShowerDefaultElevation: 900 mm
Type - Dimensions - NominalDepth: 545.692 mm; NominalHeight: 1162.51 mm; NominalWidth: 291.051 mm
Type - General - Author: BIMStone; BIMObjectName: 7401GL(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150104442; EN Standard: EN 1111, EN 1112, EN 1113; Noise Class: I (ISO 3822); RSK Number: 8283346; Sales Package dimensions (LxWxH): 1154 x 383 x 98; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7401GL; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/189423_7401GL_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7401GL
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7401GL; 3D View: https://static.oras.com/AR/7401GL; Catalog Drawing URL: http://static.oras.com/catdrw/7401GL; Dimension Drawing URL: http://static.oras.com/dimdrw/7401GL; FDV Document URL: http://www.oras.com/datasheet/7401GL/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7401GL; Group: Shower system; Installation and Maintenance Guide URL: http://static.oras.com/manual/7401GL; Interactive AR View URL: https://static.oras.com/AR/7401GL; Manufacturer: Oras; Market: International;Sweden; Mobile Product Information URL: http://mpi.oras.com/7401GL; Model: 7401GL Shower system; Name_en: 7401GL Shower system; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7401GL; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7401GL; Product URL: http://static.oras.com/7401GL; Spare-Part Information URL: http://static.oras.com/sp/7401GL; Technical DataSheet URL: http://www.oras.com/datasheet/7401GL/en; Type Name: 7401GL Shower system; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Flexible length / can be shortened; Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread; Connection Size: G3/4; Diverter: Turn operated diverter;Integrated into flow control handle; Eco Flow At 300kPa: 0.00282517 m3/s; Excluded Items: Without couplings; Flow Rate At 300kPa: 0.00494405 m3/s; Hand Shower Size: Ø 70 mm; Installation Type: Wall mounted; Installation Width: CC150± 3 mm; Lever Handle: Temperature control handle;Flow control handle;Eco feature for water flow; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Over Head Shower Size: Ø 200 mm; Pressure Loss With Flow 02ls: 300000 Pa; Shower Parts: Hand shower;Shower rail;Overhead shower;Adjustable shower rail bracket;Shower hose (1750 mm);Variable fixing points;Rotatable ball joint connection;Anti limescale technology (easy to clean); Shower Spray: EcoSpray; Shower Spray Number: 1 shower spray; Spout Projection: 435 - 460 mm; Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7401GL(2023); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7401GL; Name: 7401GL Shower system; ReplacementCost: n/a; Shape: Sculptured; Size: 290x545x1165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 1.13518 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.184666 m3
Identity Data - Mark: 36
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7401GL(2023): 7401GL Shower system; Family and Type: 7401GL(2023): 7401GL Shower system; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7401GL(2023): 7401GL Shower system; Type Id: 7401GL(2023): 7401GL Shower system; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
